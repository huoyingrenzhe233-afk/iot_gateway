# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\System;.\Hardware;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group System
    ./System/: Delay.c Delay.h ParseCmd.h ParseCmd.c
  group Hardware
    ./Hardware/: LED.c LED.h OLED.c OLED.h OLED_Font.h Key.c Key.h ESP8266.c ESP8266.h RTC_Controller.c RTC_Controller.h USART_Model.c USART_Model.h BreathLED.c BreathLED.h dianji.h dianji.c Buzzer.h Buzzer.c TempSensor.h TempSensor.c RedSensor.h RedSensor.c AHT30.c AHT30.h crc.h crc.c ADC.c ADC.h DMA.h DMA.c ZigBee.c ZigBee.h
  group FreeRTOS/inc
    ./FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/: heap_4.c port.c portmacro.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0, Data Exchange:JSON:cJSON 1.7.7
